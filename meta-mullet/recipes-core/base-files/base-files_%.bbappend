FILESEXTRAPATHS:prepend:mullet := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:mullet = "mullet"
