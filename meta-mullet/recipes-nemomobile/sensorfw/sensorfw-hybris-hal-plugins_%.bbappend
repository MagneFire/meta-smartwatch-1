FILESEXTRAPATHS:prepend:mullet := "${THISDIR}/sensorfw:"
SRC_URI:append:mullet = " file://sensorfwd.service"
