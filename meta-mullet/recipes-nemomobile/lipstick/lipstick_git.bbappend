RDEPENDS:${PN}:append:mullet = " qt5-qpa-hwcomposer-plugin "
