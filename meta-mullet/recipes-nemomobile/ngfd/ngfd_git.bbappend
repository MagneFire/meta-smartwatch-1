RDEPENDS:${PN}:append:mullet = " ngfd-plugin-droid-vibrator "
