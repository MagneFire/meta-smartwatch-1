FILESEXTRAPATHS:prepend:mullet := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:mullet = " file://default.conf"
