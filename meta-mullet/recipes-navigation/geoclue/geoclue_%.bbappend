RDEPENDS:${PN}:append:mullet = " geoclue-provider-hybris-hal "
