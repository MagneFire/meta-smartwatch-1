FILESEXTRAPATHS:prepend:minnow := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:minnow = "minnow"
#RDEPENDS:${PN}:remove:minnow = "android-tools-adbd"
