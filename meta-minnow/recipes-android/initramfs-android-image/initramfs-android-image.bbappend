#IMAGE_INSTALL:remove:minnow = "android-tools bash"
